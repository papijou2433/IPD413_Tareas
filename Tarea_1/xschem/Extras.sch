v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 -190 0 -190 150 {}
L 4 -190 150 0 150 {}
L 4 190 0 190 150 {}
L 4 0 150 190 150 {}
L 4 -190 -150 -190 0 {}
L 4 -190 -150 0 -150 {}
L 4 190 -150 190 0 {}
L 4 0 -150 190 -150 {}
C {/workspaces/usm-vlsi-tools/shared_xserver/IPD413_202501/xschem/Tareas/Tarea_1/Length_sweep.sym} -40 -110 0 0 {name=x1}
C {/workspaces/usm-vlsi-tools/shared_xserver/IPD413_202501/xschem/Tareas/Tarea_1/W_id-vs-gm_id.sym} -10 40 0 0 {name=x2}
C {/workspaces/usm-vlsi-tools/shared_xserver/IPD413_202501/xschem/Tareas/Tarea_1/gm_id-vs-Vov.sym} -10 -40 0 0 {name=x3}
C {/workspaces/usm-vlsi-tools/shared_xserver/IPD413_202501/xschem/Tareas/Tarea_1/DC_hv_mos.sym} -10 40 0 0 {name=x4}
